Commit message: Fix: changed mesh path

File: nightvapor_description/urdf/nightvapor.urdf (robot description, URDF)
Before this commit: robot nvp, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://nightvapor_description/meshes/fullnightvapor.dae scale=5 5 5
